require linux-yocto-nxp-imx7.inc

KBRANCH:nxp-imx7  = "v6.1/standard/nxp-sdk-6.1/nxp-soc"
