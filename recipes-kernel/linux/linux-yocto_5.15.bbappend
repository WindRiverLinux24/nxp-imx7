require linux-yocto-nxp-imx7.inc

KBRANCH:nxp-imx7  = "v5.15/standard/nxp-sdk-5.15/nxp-soc"
