require linux-windriver-nxp-imx7.inc
