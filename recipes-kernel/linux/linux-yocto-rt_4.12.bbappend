require linux-yocto-nxp-imx7.inc

KBRANCH_nxp-imx7 = "standard/preempt-rt/sdk-4.9.11/nxp-imx7"
