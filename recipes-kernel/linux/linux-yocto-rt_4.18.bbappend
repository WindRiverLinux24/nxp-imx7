require linux-yocto-nxp-imx7.inc

KBRANCH_nxp-imx7 = "standard/preempt-rt/nxp-imx/sdk-4.14.78/nxp-imx7"
