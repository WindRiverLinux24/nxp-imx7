require linux-yocto-nxp-imx7.inc

KBRANCH:nxp-imx7  = "v6.6/standard/nxp-sdk-6.6/nxp-soc"
