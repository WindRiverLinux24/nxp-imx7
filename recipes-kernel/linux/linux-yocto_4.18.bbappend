require linux-yocto-nxp-imx7.inc

KBRANCH_nxp-imx7 = "v4.18/standard/nxp-imx/sdk-4.14.78/nxp-imx7"
