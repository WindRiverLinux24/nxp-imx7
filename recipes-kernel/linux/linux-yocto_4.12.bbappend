require linux-yocto-nxp-imx7.inc

KBRANCH_nxp-imx7  = "standard/nxp-imx/sdk-4.9.11/nxp-imx7"
