require linux-yocto-nxp-imx7.inc

KBRANCH:nxp-imx7  = "v6.6/standard/preempt-rt/nxp-sdk-6.6/nxp-soc"
